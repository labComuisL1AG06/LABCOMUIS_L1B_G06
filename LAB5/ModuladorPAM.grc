options:
  parameters:
    author: Jorge Peña
    category: '[Modulos_L1B_G6]'
    generate_options: hb
    id: ModuladorPAM
    output_language: python
    title: ModuladorPAM
  states: {}

blocks:
- name: D
  id: parameter
  parameters:
    label: Ancho del pulso
    type: intx
    value: '10'
  states: {}
- name: Fs
  id: parameter
  parameters:
    label: Frecuencia al cuadrado
    value: '100000'
  states: {}
- name: Samp_rate
  id: parameter
  parameters:
    label: Frecuencia de muestreo
    value: '10000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fs
    offset: '0'
    phase: '0'
    samp_rate: Samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 50-D
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
